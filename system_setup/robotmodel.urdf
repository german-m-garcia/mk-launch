Commit message: odometry

File: system_setup/robotmodel.urdf (robot description, URDF)
Before this commit: robot tank1, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://system_setup/meshes/robot.stl
